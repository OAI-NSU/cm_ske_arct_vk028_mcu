# Keil uVision project cm_ske_luna_vk028_mcu.uvprojx, settings and files
target 1921vk028(Flash) (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1921VK028 Generic
  pack: NIIET.K1921VK028_DFP.1.1.4
  cpu: IRAM(0x20000000,0xA0000) IRAM2(0x13000000,0x10000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cm_ske_arct_vk028_mcu +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS\Core\Include;.\Sources;.\Sources\CM4;.\TaskPlanner
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  memory RVCT10: RAM 0x13000000 size 0x10000
  group Source
    ./Sources/: main.c uart.c adc.c mko_bc.c mko_rt.c gpio.c clock.c timers.c cm.c frames.c power_management.c pwr_channel.c termo_res.c wdt.c frame_mem.c spi.c spi_fram.c internal_bus.c stm.c crc16.c bdd.c ddii.c dep.c mpp.c dir.c gen_mpp.c
  group CM4
    ./Sources/CM4/: startup_K1921VK028.s system_K1921VK028.c system_K1921VK028.h K1921VK028.h retarget.c retarget_conf.c retarget_conf.h
  group CMSIS
    ./CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_cmcpp.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group TaskPlanner
    ./TaskPlanner/: cyclogramma.c flight_task.c task_planner.c byteswap.c byteswap.h cyclogramma.h flight_task.h task_planner.h
target 1921vk028(extmem) (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1921VK028 Generic
  pack: NIIET.K1921VK028_DFP.1.1.4
  cpu: as above
  output: cm_bakv_mcu_extmem +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS\Core\Include;.\Sources;.\Sources\CM4;.\TaskPlanner
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\my_vk028_proj(flash).sct
